# Keil uVision project usblib.uvproj, settings and files
target usblib (ARM-ADS)
  device: TM4C1230C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: usblib (library)
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: rvmdk
  c misc: --c99
  c include: ..;..\..\..\..;C:\ti\TivaWare_C_Series\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: usbbuffer.c usbdesc.c usbdma.c usbkeyboardmap.c usbmode.c usbringbuf.c usbtick.c usbulpi.c
    ./device/: usbdaudio.c usbdbulk.c usbdcdc.c usbdcdesc.c usbdcomp.c usbdconfig.c usbddfu-rt.c usbdenum.c usbdhandler.c usbdhid.c usbdhidgamepad.c usbdhidkeyb.c usbdhidmouse.c usbdmsc.c
    ./host/: usbhaudio.c usbhhid.c usbhhidkeyboard.c usbhhidmouse.c usbhhub.c usbhmsc.c usbhostenum.c usbhscsi.c
  group Documentation
    ./: readme.txt
